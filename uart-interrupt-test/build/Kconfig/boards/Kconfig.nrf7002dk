## uart-interrupt-test/build/Kconfig/boards/Kconfig.nrf7002dk
```kconfig
# Load board Kconfig descriptions.
osource "C:/ncs/v3.1.1/zephyr/boards/nordic/nrf7002dk/Kconfig.nrf7002dk"
```
